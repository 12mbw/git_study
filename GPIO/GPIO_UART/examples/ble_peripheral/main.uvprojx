# Keil uVision project main.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x12000000,0x08000000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1
  c define: BOARD_PCA10056 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\components;..\..\components\drivers_nrf;..\..\components\libraries\bsp;..\..\components\libraries\delay;..\..\config\nrf52840;..\..\config\nrf52840\armgcc;..\..\integration\nrfx\legacy;..\..\integration;..\..\integration\nrfx;..\..\modules;..\..\modules\nrfx;..\..\modules\nrfx\drivers;..\..\modules\nrfx\drivers\include;..\..\modules\nrfx\hal;..\..\modules\nrfx\templates;..\..\modules\nrfx\templates\nRF52840;..\..\config\nrf52840\config;..\..\components\libraries\util;..\..\components\drivers_nrf\nrf_soc_nosd;..\..\components\libraries\fifo;..\..\integration\nrfx\legacy;..\..\modules\nrfx\drivers\src\prs;..\..\components\libraries\uart;..\..\components\boards
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10056,-DBSP_DEFINES_ONLY,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
  group main
    ./: main.c
    ../../config/nrf52840/config/: sdk_config.h
  group drive
    ../../drive/: nrfx_prs.c nrfx_uart.c nrfx_uarte.c nrf_drv_uart.c
  group lib
    ../../components/libraries/delay/: nrf_delay.h
    ../bsp/: app_fifo.c app_uart_fifo.c retarget.c
  group nrf_board
    ../../components/boards/: boards.c
software components: CMSIS:CORE 5.6.0, Device:Startup 8.44.1
